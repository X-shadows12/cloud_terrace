# Keil uVision project ctm_app.uvprojx, settings and files
target ctm_app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ctm_app_fw +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bincombined "!L" --output="$L\@L.bin"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32H7XX,GD32H7XXI,ARM_MATH_CM7
  c misc: --c99
  c include: ..\Source;..\CMSIS;..\CMSIS\GD\GD32H7xx\Include;..\GD32H7xx_standard_peripheral\Include;..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application
    ../Source/: main.c gd32h7xx_it.c pwm_curr.c controller.c encoder.c mc_task.c trapTraj.c calibration.c anticogging.c heap.c foc.c can.c dfu.c util.c usr_config.c rtt_scope.c
  group GD32H7xx_StdPeriph_Driver
    ../GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_dbg.c gd32h7xx_dma.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_trigsel.c
  group CMSIS
    ../CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Startup
    ../CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Conf.h
